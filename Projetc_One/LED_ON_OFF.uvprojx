# Keil uVision project LED_ON_OFF.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_ON_OFF
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\COTS\01. MCAL\GPIO;..\COTS\01. MCAL\GPTM;..\COTS\01. MCAL\NVIC;..\COTS\01. MCAL\SYS_Ctrl;..\COTS\00. Common;..\COTS\01. MCAL\SysTick
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ../COTS/01. MCAL/GPIO/: DIO_Program.c
    ../COTS/01. MCAL/GPTM/: GPTM_Program.c
    ../COTS/01. MCAL/NVIC/: NVIC_Program.c
    ../COTS/01. MCAL/SYS_Ctrl/: SYS_Ctrl.c
    ../COTS/01. MCAL/SysTick/: SysTick.c
  group APP
    ../COTS/04. APP/: main.c
  group Config
    ../COTS/01. MCAL/NVIC/: IntCtrl_Lcfg.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
